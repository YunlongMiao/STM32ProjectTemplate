# Keil uVision project HalTemplateProject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HalTemplateProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\User;..\Drivers;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Middlewares;..\Drivers\SYSTEM\delay;..\Drivers\SYSTEM\sys;..\Drivers\SYSTEM\usart;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\port\MemMang;..\Middlewares\FreeRTOS\port\RVDS\ARM_CM4F;..\Middlewares\FreeRTOS\src;..\Middlewares\FreeRTOS;..\Drivers\SYSTEM\CallBack;..\Drivers\SYSTEM\init;..\Drivers\SYSTEM\public;..\Drivers\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Starup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h MyTask.c
    ../User/: main.c stm32f4xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_timebase_tim.c
  group MyApp
    ../Drivers/BSP/: gGpio.c
  group Driver/SYSTEM
    ../Drivers/SYSTEM/init/: MyApplication.h MyInit.c
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: usart.c
    ../Drivers/SYSTEM/CallBack/: CallBack.c
    ../Drivers/SYSTEM/public/: Public.c
  group Driver/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group FreeRTOS/port
    ../Middlewares/FreeRTOS/port/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/src
    ../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
