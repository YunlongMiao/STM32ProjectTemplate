# Keil uVision project SelfLEDFreeRTOSTest.uvprojx, settings and files
target SelfLEDFreeRTOSTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SelfLEDFreeRTOSTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\MyApplication;..\Middlewares\FreeRTOS;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\SRC;..\Middlewares\FreeRTOS\PORT\MemMang;..\Middlewares\FreeRTOS\PORT\RVDS\ARM_CM4F;..\MyApplication\SYSTEM\delay;..\MyApplication\SYSTEM\sys;..\MyApplication\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group MyApplication
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h
    ../MyApplication/: CallBack.c MyInit.c Public.c System.c MyTask.c
    ../MyApplication/SYSTEM/delay/: delay.c
    ../MyApplication/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS/port
    ../Middlewares/FreeRTOS/PORT/RVDS/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/PORT/MemMang/: heap_4.c
  group FreeRTOS/src
    ../Middlewares/FreeRTOS/SRC/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
software components: CMSIS:CORE 5.5.0
